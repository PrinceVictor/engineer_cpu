# Keil uVision project engineerVehicle.uvproj, settings and files
target engineer_cpu (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: engineer_cpu +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\Libraries;..\Vision;..\User\Inc;..\User\Src;..\log;..\User\Inc\BSP;..\User\Inc\IMU;..\User\Inc\Referee;..\User\Inc\Task;..\User\Src\BSP;..\User\Src\IMU;..\User\Src\Referee;..\User\Src\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/Src/: main.c
    ../log/: log.txt
  group Bsp
    ../User/Src/BSP/: sys.c delay.c Boot.c Clock.c Communication.c MyFunc.c IWDG.c
  group Imu
    ../User/Src/IMU/: 6050.c I2C.c Imu.c
  group Task
    ../User/Src/Task/: ControlTask.c ComunicateTask.c holder.c ChassisTask.c PidTask.c Relay.c
  group Referee
    ../User/Src/Referee/: Referee.c
  group Lib
    ../Libraries/: startup_stm32f40_41xxx.s misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_usart.c system_stm32f4xx.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_dma.c
